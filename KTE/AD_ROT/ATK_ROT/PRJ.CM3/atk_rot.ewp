# IAR project atk_rot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4078 NXP LPC4078
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _CM3_; CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161, Pe191, Pe009,Pa093,Pe068,Pe550,Pe2464
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\STANDART\; ..\..\STANDART\; ..\..\..\STANDART\; ..\..\..\..\STANDART\CM\UPTF; ..\..\..\..\STANDART\CM\; ..\..\..\..\STANDART\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: atk_rot.hex
  prebuild: ..\..\..\..\UTILITY\Dattim.exe datetime.h
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\..\..\..\STANDART\CM\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: INC.c
    ../../../../STANDART/CM/: startup_LPC407x_8x_177x_8x.s
