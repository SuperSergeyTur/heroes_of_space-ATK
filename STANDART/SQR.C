// Программа нахождения квадратного корня из длинного беззнакового
// слова. Выходное значение тоже длинное слово, первый байт которого
// дробный. Корень вычисляется из таблицы, состоящей из 256 значений.
// Номер необходимого значения в таблице получается путем нормализации
// (сдвига влево до первой единицы в старшем разряде) исходного числа
// из нормализованного значения ( число сдвигов должно быть обязательно
// четным) берется старший байт, данные операции аналогичны делению исходного
// числа на 4 до одного байта.  Из полученного результата и будем по таблице
// брать корень. Число сдвигов делим на 2 (взяли корень из 4)  и полученное
// значение сдвигаем влево на это число.
lword Sqr ( lword Znach )
{
  // Передаем исходное значение
  laq = Znach ;
  // Если число и так меньше байта, то и сдвигать его не стоит.
  if ( laq <= 255 )
  {
     dq = laq;
     aq = 0;
  }
  else
  {
    for(bq = 0; (slw)laq > 0; ++bq)  // нормализируем исходное значение
    {
      laq <<=1;
    }
    aq = bq/2 ;
    // Если сдвинули нечетное число раз, то один раз возвращаем
    if (  (bq & 0x01) == 1)
    {
      laq >>=1;
    }
    // Т.к. мы сдвигали влево, то половину проделаных сдвигов
    // вычитаем из 12 (число пар сдвигов числа FFFFдо байта)
    aq =12 - aq;
    dq = laq >> 24;
  }
  // Берем корень из полученного числа
  dq = _sqrt_tab[dq];
  // Домножаем на 2^aq
  laq = (lw)dq << aq;

  return laq;

}
